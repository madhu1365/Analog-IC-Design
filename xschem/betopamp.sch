v {xschem version=3.4.8RC file_version=1.2}
G {}
K {}
V {}
S {}
E {}
N 170 -160 240 -160 {lab=vop}
N 170 -100 240 -100 {lab=vom}
C {vcvs.sym} 170 -130 0 0 {name=E1 value=1000
}
C {iopin.sym} 130 -150 2 0 {name=p1 lab=vip}
C {iopin.sym} 130 -110 2 0 {name=p2 lab=vim}
C {iopin.sym} 240 -160 0 0 {name=p3 lab=vop}
C {iopin.sym} 240 -100 0 0 {name=p4 lab=vom}
