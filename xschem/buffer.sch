** sch_path: xschem/buffer.sch
**.subckt buffer
E1 net2 net3 net4 net5 1000
E2 net1 net3 net6 net7 1000
C1 net1 net3 1p m=1
R1 net2 net1 1k m=1
**.ends
.end
